* Fontes para a validacao logica do circuito T = generico

*-------------------------------------------------------------------------------
* Declaracao das fontes DC
*-------------------------------------------------------------------------------
Vvdd1 vdd1 gnd supply
Vvdd2 vdd2 gnd supply
Vvdd3 vdd3 gnd supply

Va a gnd 0
vb b gnd 0.85
