*--------------------------------------------------------------
* Declaracao fonte DC (source signal)
*--------------------------------------------------------------
Vvdd1 vdd1 gnd supply
Vvdd2 vdd2 gnd supply
Vvdd3 vdd3 gnd supply

Va a gnd 0.7
Vb b gnd 0
